# Keil uVision project Universal Bus Converter.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Universal Bus Converter
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.cpp std_types.h Debug.c Debug.h
  group COM
    ./: BASE_COM.h COM_Generic.h BASE_COM.cpp UART_COM.h UART_COM.cpp
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:CAN 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:STM32Cube HAL:USART 1.7.13, Device:Startup 2.6.3
